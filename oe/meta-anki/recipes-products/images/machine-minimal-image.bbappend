# Camera Open Source packages
include ${BASEMACHINE}/${BASEMACHINE}-anki-image.inc

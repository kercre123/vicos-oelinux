# Data proprietary PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-robot-data-image.inc

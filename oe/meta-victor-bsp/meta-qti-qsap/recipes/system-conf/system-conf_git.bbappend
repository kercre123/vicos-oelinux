FILESPATH_prepend := "${THISDIR}/system-conf:"
SRC_URI_append = " \
    file://001_open_ssid.patch \
    "

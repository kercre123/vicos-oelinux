include ${BASEMACHINE}/${BASEMACHINE}-scve-prop-image.inc

# scve-noship PROP PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-scve-prop-image.inc

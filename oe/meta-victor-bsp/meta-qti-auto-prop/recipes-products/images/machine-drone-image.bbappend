# Auto proprietary source Packages
include ${BASEMACHINE}/${BASEMACHINE}-auto-image.inc
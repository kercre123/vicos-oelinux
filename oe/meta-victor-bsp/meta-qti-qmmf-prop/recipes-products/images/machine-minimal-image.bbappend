# List of qmmf proprietary packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-qmmf-prop-image.inc

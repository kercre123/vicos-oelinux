# qmmf proprietary SOURCE PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-qmmf-prop-image.inc

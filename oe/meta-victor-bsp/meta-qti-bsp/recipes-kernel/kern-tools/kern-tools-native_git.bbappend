PR = "r14"

SRC_URI = "${CAF_GIT}/platform/external/yocto-kernel-tools;protocol=git;branch=yocto/master"

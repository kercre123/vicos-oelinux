FILESEXTRAPATHS_prepend := "${THISDIR}/openssh:"
SRC_URI += "file://sshd_config"

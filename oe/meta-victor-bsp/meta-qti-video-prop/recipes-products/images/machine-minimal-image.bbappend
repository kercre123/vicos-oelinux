# VIDEO PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-video-minimal-image.inc

# Camera proprietary packages
include ${BASEMACHINE}/${BASEMACHINE}-camera-image.inc

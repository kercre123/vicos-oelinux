#
# Common license for meta-qti-bsp-prop projects
#

HOMEPAGE         = "http://support.cdmatech.com"
LICENSE          = "Qualcomm-Technologies-Inc.-Proprietary"
LIC_FILES_CHKSUM = "file://${QCOM_LICENSES}/${LICENSE};md5=92b1d0ceea78229551577d4284669bb8"


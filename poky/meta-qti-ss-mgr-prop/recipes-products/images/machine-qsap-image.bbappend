# ss-mgr PROP PACKAGES
include ${BASEMACHINE}/${BASEMACHINE}-ss-mgr-prop-image.inc

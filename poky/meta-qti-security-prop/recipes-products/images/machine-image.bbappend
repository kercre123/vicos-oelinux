include ${BASEMACHINE}/${BASEMACHINE}-security-qti-image.inc

# higher than toybox (which is 110)
ALTERNATIVE_PRIORITY = "120"

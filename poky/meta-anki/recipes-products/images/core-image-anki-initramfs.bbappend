PACKAGE_INSTALL += " initscript-anki rampost"

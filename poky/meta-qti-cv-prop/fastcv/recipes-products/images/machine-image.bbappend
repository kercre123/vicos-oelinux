# Include the fastcv-noship project in <target>/<target>-fastcv-image.inc
# so that fastcv-noship compilation is part of the build compilation
include ${BASEMACHINE}/${BASEMACHINE}-fastcv-image.inc


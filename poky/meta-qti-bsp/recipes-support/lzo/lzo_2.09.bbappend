#Copyright (c) 2014, Linux Foundation. All rights reserved.
#Linux Foundation chooses to take subject only to the GPLv2
#license terms, and distributes only under these terms.

LICENSE_lzo = "GPLv2only"
LIC_FILES_CHKSUM = "file://COPYING;beginline=1;endline=280;md5=4641e94ec96f98fabc56ff9cc48be14b"

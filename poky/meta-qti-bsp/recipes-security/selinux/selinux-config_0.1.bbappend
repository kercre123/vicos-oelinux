DEFAULT_ENFORCING ??= "disabled"
EXTRA_OECONF = " --with-pcre --with-core-includes=${WORKSPACE}/system/core/include"

require dnsmasq.inc

SRC_URI[dnsmasq-2.73.md5sum] = "c2d56b11317336bc788ded4298642e2e"
SRC_URI[dnsmasq-2.73.sha256sum] = "9f350f74ae2c7990b1c7c6c8591d274c37b674aa987f54dfee7ca856fae0d02d"

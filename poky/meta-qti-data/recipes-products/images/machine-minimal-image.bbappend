include ${BASEMACHINE}/${BASEMACHINE}-minimal-data-image.inc
